# Keil uVision project MQTT_W7500P.uvprojx, settings and files
target MQTT_W7500P (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0")
  output: MQTT_W7500P
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DMBED_BUILD_TIMESTAMP=1535053340.05 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DTARGET_WIZNET --split_sections -D__ASSERT_MSG --no_rtti -DTARGET_WIZwiki_W7500P -DCMSIS_VECTAB_VIRTUAL_HEADER_FILE=\"cmsis_nvic.h\" -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DCMSIS_VECTAB_VIRTUAL -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M0 -DTARGET_WIZWIKI_W7500P -DDEVICE_I2C=1 -DTARGET_CORTEX -DTOOLCHAIN_ARM -D__CORTEX_M0 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_W7500x -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM
  c include: .;MQTT;MQTT/FP;MQTT/MQTTPacket;MQTT/MQTTPacket/samples;MQTT/MQTTPacket/test;WIZnetInterface;WIZnetInterface/Socket;WIZnetInterface/arch;WIZnetInterface/arch/ext;WIZnetInterface/arch/int;mbed-src;mbed-src/api;mbed-src/common;mbed-src/hal;mbed-src/targets;mbed-src/targets/cmsis;mbed-src/targets/cmsis/TARGET_WIZNET;mbed-src/targets/cmsis/TARGET_WIZNET/TARGET_W7500x;mbed-src/targets/cmsis/TARGET_WIZNET/TARGET_W7500x/TARGET_WIZwiki_W7500P;mbed-src/targets/cmsis/TARGET_WIZNET/TARGET_W7500x/TARGET_WIZwiki_W7500P/TOOLCHAIN_ARM_STD;mbed-src/targets/hal;mbed-src/targets/hal/TARGET_WIZNET;mbed-src/targets/hal/TARGET_WIZNET/TARGET_W7500x;mbed-src/targets/hal/TARGET_WIZNET/TARGET_W7500x/TARGET_WIZwiki_W7500P;mbed-src/targets/hal/TARGET_WIZNET/TARGET_W7500x/W7500x_Peripheral_Library
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-DCMSIS_VECTAB_VIRTUAL,-DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h",-D__MBED_CMSIS_RTOS_CM,-DARM_MATH_CM0,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-src/targets/cmsis/TARGET_WIZNET/TARGET_W7500x/TARGET_WIZwiki_W7500P/TOOLCHAIN_ARM_STD/W7500.sct
  link misc: --show_full_path
  group mbed-src
    mbed-src/api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h platform.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h wait_api.h
    mbed-src/targets/hal/TARGET_WIZNET/TARGET_W7500x/: analogin_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c mbed_overrides.c objects.h PeripheralNames.h PeripheralPins.h pinmap.c port_api.c PortNames.h pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    mbed-src/hal/: analogin_api.h analogout_api.h buffer.h can_api.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h us_ticker_api.h
    mbed-src/common/: assert.c board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp error.c Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp gpio.c I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp lp_ticker_api.c mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp ticker_api.c Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
    mbed-src/targets/cmsis/TARGET_WIZNET/TARGET_W7500x/: cmsis.h cmsis_nvic.c cmsis_nvic.h system_W7500x.c system_W7500x.h W7500x.h
    mbed-src/targets/cmsis/: core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    mbed-src/targets/hal/TARGET_WIZNET/TARGET_W7500x/TARGET_WIZwiki_W7500P/: device.h PeripheralPins.c PinNames.h
    mbed-src/targets/cmsis/TARGET_WIZNET/TARGET_W7500x/TARGET_WIZwiki_W7500P/TOOLCHAIN_ARM_STD/: startup_W7500x.S sys.cpp
    mbed-src/targets/hal/TARGET_WIZNET/TARGET_W7500x/W7500x_Peripheral_Library/: W7500x_adc.c W7500x_adc.h W7500x_conf.h W7500x_crg.c W7500x_crg.h W7500x_dualtimer.c W7500x_dualtimer.h W7500x_exti.c W7500x_exti.h W7500x_gpio.c W7500x_gpio.h W7500x_i2c.c W7500x_i2c.h W7500x_pwm.c W7500x_pwm.h W7500x_uart.c W7500x_uart.h
  group MQTT
    MQTT/FP/: FP.h
    MQTT/: MQTTAsync.h MQTTClient.h MQTTEthernet.h MQTTLogging.h MQTTmbed.h MQTTSocket.h
    MQTT/MQTTPacket/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group MQTT_W7500P
    ./: main.cpp
    /arm/w7500/MQTT_W7500P/: mbed_config.h
  group WIZnetInterface
    WIZnetInterface/Socket/: DHCPClient.cpp DHCPClient.h DNSClient.cpp DNSClient.h dnsname.h Endpoint.cpp Endpoint.h pico_string.h Socket.cpp Socket.h TCPSocketConnection.cpp TCPSocketConnection.h TCPSocketServer.cpp TCPSocketServer.h UDPSocket.cpp UDPSocket.h
    WIZnetInterface/: eth_arch.h EthernetInterface.cpp EthernetInterface.h
    WIZnetInterface/arch/ext/: W5500.cpp W5500.h
    WIZnetInterface/arch/int/: W7500x_toe.cpp W7500x_toe.h
